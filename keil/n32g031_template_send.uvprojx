# Keil uVision project n32g031_template_send.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: N32G031K8 NSING
  pack: NSING.N32G031_DFP.1.0.5
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: keil
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=8 wLevel=1
  c include: ../Core/inc;../Core/inc/send
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ../Core/src/: n32g031_it.c ring_buffer.c util.cpp
    ../Core/src/send/: main.c
software components: CMSIS:CORE 6.1.0, Device:N32G031_StdPeripherals:ADC 1.0.0, Device:N32G031_StdPeripherals:BEEPER 1.0.0, Device:N32G031_StdPeripherals:COMP 1.0.0, Device:N32G031_StdPeripherals:CRC 1.0.0, Device:N32G031_StdPeripherals:DBG 1.0.0, Device:N32G031_StdPeripherals:DMA 1.0.0, Device:N32G031_StdPeripherals:EXTI 1.0.0, Device:N32G031_StdPeripherals:FLASH 1.0.0, Device:N32G031_StdPeripherals:GPIO 1.0.0, Device:N32G031_StdPeripherals:HDIV 1.0.0, Device:N32G031_StdPeripherals:I2C 1.0.0, Device:N32G031_StdPeripherals:IWDG 1.0.0, Device:N32G031_StdPeripherals:LPTIM 1.0.0, Device:N32G031_StdPeripherals:LPUART 1.0.0, Device:N32G031_StdPeripherals:MISC 1.0.0, Device:N32G031_StdPeripherals:OPAMP 1.0.0, Device:N32G031_StdPeripherals:PWR 1.0.0, Device:N32G031_StdPeripherals:RCC 1.0.0, Device:N32G031_StdPeripherals:RTC 1.0.0, Device:N32G031_StdPeripherals:SPI 1.0.0, Device:N32G031_StdPeripherals:TIMER 1.0.0, Device:N32G031_StdPeripherals:USART 1.0.0, Device:N32G031_StdPeripherals:WWDG 1.0.0, Device:Startup 1.0.0
